# IAR project richi_light.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\System\Libraries\STM8S_StdPeriph_Driver\inc; ..\Lib\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: richi_light.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group Bsp
    ../System/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group Lib
    ../Lib/src/: delay.c irda.c led.c pwm.c RF24L01.c spi.c USART.c
